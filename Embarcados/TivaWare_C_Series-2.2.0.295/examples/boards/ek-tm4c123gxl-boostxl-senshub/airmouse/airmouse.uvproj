# Keil uVision project airmouse.uvproj, settings and files
target airmouse (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: airmouse
  AfterMake: fromelf --bin --output .\rvmdk\airmouse.bin .\rvmdk\airmouse.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: airmouse.sct
  link misc: --entry Reset_Handler
  group Source
    ./: airmouse.c lprf.c motion.c remoti_npi.c remoti_rtis.c remoti_uart.c startup_rvmdk.S usb_dev_comp_hid.c usb_structs.c
    ../drivers/: buttons.c rgb.c
    ../../../../utils/: ringbuf.c uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
