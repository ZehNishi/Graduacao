# Keil uVision project pressure_bmp180.uvproj, settings and files
target pressure_bmp180 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: pressure_bmp180
  AfterMake: fromelf --bin --output .\rvmdk\pressure_bmp180.bin .\rvmdk\pressure_bmp180.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: pressure_bmp180.sct
  link misc: --entry Reset_Handler
  group Source
    ./: pressure_bmp180.c startup_rvmdk.S
    ../drivers/: rgb.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
